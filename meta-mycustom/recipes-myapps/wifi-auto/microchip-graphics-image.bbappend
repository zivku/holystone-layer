IMAGE_INSTALL:append:sam9x60-curiosity = " wifi"
IMAGE_INSTALL:append:sam9x60-curiosity = " init"

