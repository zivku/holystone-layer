IMAGE_INSTALL:append = " sqlite3 libsqlite3"
