IMAGE_INSTALL:append = " sqlite3 libsqlite3"
IMAGE_INSTALL:append = " tzdata"
