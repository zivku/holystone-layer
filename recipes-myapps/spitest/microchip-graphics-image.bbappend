IMAGE_INSTALL:append:sam9x60-curiosity-sd = " myapp"

