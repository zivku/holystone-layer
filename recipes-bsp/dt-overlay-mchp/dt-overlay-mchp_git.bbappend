FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " \
    file://0001-sam9x60-update-overlay-for-LCD-Touch.patch \
"
