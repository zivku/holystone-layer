FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
require u-boot-envs-mycustom.inc
